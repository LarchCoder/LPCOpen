# Keil uVision project lib_lpcspifi_M0.uvprojx, settings and files
target lib_lpcspifi_M0 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: lib_lpcspifi_M0 (library)
  AfterMake: cmd /c copy !L ..\lib\keil
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0
  c misc: --gnu
  c include: .;..\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ../src/: spifilib_dev_common.c spifilib_fam_standard_cmd.c
