<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_board\boards_43xx\nxp_lpcxpresso_4337\lib_lpc_board_nxp_lpcxpresso_4337.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\lib_lpc_chip_43xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\adc\adc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\aes\aes.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\atimer\atimer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\blinky\blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\i2cm_interrupt\i2cm_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\i2cm_polling\i2cm_polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\timers\timers.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\ccan\ccan.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\dac\dac.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\flashiap\flashiap.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\grouped_int\grouped_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\i2c\i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\pinint\pinint.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\ritimer\ritimer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\rtc\rtc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\sct_pwm\sct_pwm.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\sdmmc\sdmmc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\ssp\ssp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\systick\systick.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\uart\uart.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\uart_rb\uart_rb.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\watchdog\watchdog.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>lib_lpc_chip_43xx</project>
        <configuration>chip_43xx_lib</configuration>
      </member>
      <member>
        <project>lib_lpc_board_nxp_lpcxpresso_4337</project>
        <configuration>nxp_lpcxpresso_4337</configuration>
      </member>
      <member>
        <project>adc</project>
        <configuration>iflash_nxp_lpcxpresso_4337</configuration>
      </member>
      <member>
        <project>aes</project>
        <configuration>iflash_nxp_lpcxpresso_4337</configuration>
      </member>
      <member>
        <project>atimer</project>
        <configuration>iflash_nxp_lpcxpresso_4337</configuration>
      </member>
      <member>
        <project>blinky</project>
        <configuration>iflash_nxp_lpcxpresso_4337</configuration>
      </member>
      <member>
        <project>ccan</project>
        <configuration>iflash_nxp_lpcxpresso_4337</configuration>
      </member>
      <member>
        <project>dac</project>
        <configuration>iflash_nxp_lpcxpresso_4337</configuration>
      </member>
      <member>
        <project>flashiap</project>
        <configuration>iflash_nxp_lpcxpresso_4337</configuration>
      </member>
      <member>
        <project>grouped_int</project>
        <configuration>iflash_nxp_lpcxpresso_4337</configuration>
      </member>
      <member>
        <project>i2c</project>
        <configuration>iflash_nxp_lpcxpresso_4337</configuration>
      </member>
      <member>
        <project>i2cm_interrupt</project>
        <configuration>iflash_nxp_lpcxpresso_4337</configuration>
      </member>
      <member>
        <project>i2cm_polling</project>
        <configuration>iflash_nxp_lpcxpresso_4337</configuration>
      </member>
      <member>
        <project>pinint</project>
        <configuration>iflash_nxp_lpcxpresso_4337</configuration>
      </member>
      <member>
        <project>ritimer</project>
        <configuration>iflash_nxp_lpcxpresso_4337</configuration>
      </member>
      <member>
        <project>rtc</project>
        <configuration>iflash_nxp_lpcxpresso_4337</configuration>
      </member>
      <member>
        <project>sct_pwm</project>
        <configuration>iflash_nxp_lpcxpresso_4337</configuration>
      </member>
      <member>
        <project>sdmmc</project>
        <configuration>iflash_nxp_lpcxpresso_4337</configuration>
      </member>
      <member>
        <project>ssp</project>
        <configuration>iflash_nxp_lpcxpresso_4337</configuration>
      </member>
      <member>
        <project>systick</project>
        <configuration>iflash_nxp_lpcxpresso_4337</configuration>
      </member>
      <member>
        <project>timers</project>
        <configuration>iflash_nxp_lpcxpresso_4337</configuration>
      </member>
      <member>
        <project>uart</project>
        <configuration>iflash_nxp_lpcxpresso_4337</configuration>
      </member>
      <member>
        <project>uart_rb</project>
        <configuration>iflash_nxp_lpcxpresso_4337</configuration>
      </member>
      <member>
        <project>watchdog</project>
        <configuration>iflash_nxp_lpcxpresso_4337</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


